# Keil uVision project project.uvprojx, settings and files
target STM32F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: /Drivers;/Libs;Drivers;Libs;HAL;/HAL;Waveforms;/Waveforms;Filters;/Filters;BSP;/BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./App/: main.c
  group Waveforms
    ./Waveforms/: waveforms.c sine_generator.c sine_generator.h
  group HAL
    ./HAL/: clock.h clock.c
  group Filters
    ./Filters/: lowpassFilter.c lowpassFIlter.h
  group BSP
    ./BSP/: leds.c leds.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:Startup 2.6.3
